# Keil uVision project tutorial.uvproj, settings and files
target Blink_LED_7Seg (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: NUC140VE3CN Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: tutorial
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: fromelf --text -c ".\Objects\@L.axf" --output ".\Objects\@L.txt"
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\;..\CoreSupport;..\NUC1xx;..\Include;..\Include\Driver;..\Src\Driver;..\NUC1xx\startup\arm;..\Src\NUC1xx-LB_002;..\Include\NUC1xx-LB_002
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_NUC1xx.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ./: startup_NUC1xx.s
    ../CoreSupport/: core_cm0.c
    ../NUC1xx/: system_NUC1xx.c
  group Library
    ../Src/Driver/: DrvGPIO.c DrvSYS.c DrvADC.c DrvPWM.c DrvUART.c DrvTIMER.c
  group Source
    ./: tutorial.c
    ../Src/NUC1xx-LB_002/: ScanKey.c Seven_Segment.c LCD_Driver.c Ascii_Table.C
